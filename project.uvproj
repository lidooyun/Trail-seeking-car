# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\hardware;.\user;.\os
  group user
    ./user/: main.c app.h app_key_task.c app_user_uart_task.c app_bluetooth_task.c app_bat_task.c app_track_task.c
  group os
    ./os/: Conf_tny.A51 RTX51TNY.LIB
  group lib
    ./lib/: UART_Isr.c Delay.c GPIO.c NVIC.c STC8H_PWM.c STC8H_PWM_Isr.c UART.c ADC.c ADC_Isr.c
  group hardware
    ./hardware/: motor.c bluetooth.c bat.c track.c Ultrasonic.c user_uart.c buzzer.c key.c led.c
